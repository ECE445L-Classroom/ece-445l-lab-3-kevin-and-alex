# Keil uVision project Lab3.uvprojx, settings and files
target Lab3 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab3Main.c LCD.c LCD.h Image.h Systick.c Systick.h Speaker.c Speaker.h Switch.c
    ../inc/: PLL.c Timer0A.c ST7735.c Timer1A.c Timer2A.c
software components: CMSIS:CORE 6.1.0
